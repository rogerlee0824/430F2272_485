# IAR project WirelessAmmeter.ewp, settings and files
configuration WirelessMeter_430f2272_485 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2272 MSP430F2272
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CONFIG_1
  ICC430.newCCIncludePaths: src\app\; src\driver\; src\os\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2272.xcl
  XLINK.XlinkStackSize: 1
  group app
    src/app/: init.c main.c
  group driver
    src/driver/: cc1120_rx_sniff_mode_rx.c cc112x_spi.c crc16.c delay.c hal_spi_rf_trxeb.c rs485.c uart.c
